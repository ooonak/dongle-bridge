## app/tests/app_logic/testcase.yaml
```yaml
tests:
  app_logic.unit:
    platform_allow:
      - native_sim
    harness: ztest
    tags:
      - unit
      - app_logic
```
